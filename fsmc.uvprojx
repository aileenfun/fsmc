# Keil uVision project fsmc.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: fsmc
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\include;.\fwlib\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group start_up
    ./: startup_stm32f40_41xxx.s
  group main
    ./main/: main.c
  group driver
    ./driver/: fsmc.c led.c stm32f4xx_it.c system_stm32f4xx.c timer3.c systick.c exti.c bsp_internalFlash.c adc.c delay.c
    ./driver/1-wire_driver/common/: one_wire_crc.c one_wire_hal.c one_wire_net.c one_wire_rom_func.c
    ./: fpga2cpu_cmd.c
  group fwlib
    ./fwlib/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_adc.c
  group include
    ./include/: fpga2cpu_cmd.h adc.h bsp_internalFlash.h exti.h fsmc.h led.h main.h systick.h timer3.h delay.h
    ./driver/1-wire_driver/common/: one_wire_crc.h one_wire_def.h one_wire_hal.h one_wire_net.h one_wire_rom_func.h
software components: CMSIS:CORE 4.3.0
